Properties of the parts of a building model (IFC4)

# File
Description: Schaltschrankthermostat elektronisch für Peltiermodule – Heizen oder Kühlen. 24 VDC, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: DN600007, Schaltschrankthermostat elektronisch für Peltiermodule – Heizen oder Kühlen. 24 VDC
In: Raum
Description: Dieser Temperaturregler wurde speziell zur Ansteuerung von Peltiermodulen, zum Heizen oder Kühlen von Schaltschränken, Fahrkarten- und Geldautomaten oder zur Heiz-/Kühlmeldungen bzw. Anforderungen entwickelt. Der Regler kann nur für eine Betriebsart Heizen oder Kühlen eingesetzt werden.; Classification: EC004587 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: DN600007; ModelLabel: CTRRS-161.000/06; GlobalTradeItemNumber: 4050528078056; ProductURL: https://alre.de/produkt_DN600007
Pset_Specification - NominalLength: 0.064 m; NominalWidth: 0.046 m; NominalDepth: 0.037 m; NetWeight: 0.071
Pset_ALRE_ETIM_Properties - Montageart: Klemmbefestigung; Ausführung: Thermostat; Ausführung der Schaltfunktion: Wechsler (NO/NC); Bemessungsspannung DC: 24; Einstellbereich Temperatur: 0; ETIM-Klasse: EC004587; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-DN600007.pdf
